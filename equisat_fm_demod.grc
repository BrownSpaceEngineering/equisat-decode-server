<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>equisat_fm_demod</value></param>
<param><key>description</key><value>This flowgraph generates the flowgraph used in decode.py</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>0.050</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_depth</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>variable_rrc_filter_taps_0</value></param>
<param><key>alpha</key><value>0.2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>symbol_depth*(sample_rate/decimation/4800)</value></param>
<param><key>samp_rate</key><value>sample_rate/decimation</value></param>
<param><key>sym_rate</key><value>4800</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>10</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>wavfile</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>gain_mu</value></param>
<param><key>gain_omega</key><value>0.25*gain_mu*gain_mu</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>(sample_rate/decimation)/4800.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>equisat_decoder_equisat_4fsk_block_decode</key>
<param><key>id</key><value>equisat_decoder_equisat_4fsk_block_decode_0</value></param>
<param><key>msg_size</key><value>255</value></param>
<param><key>print_packets</key><value>False</value></param>
</block>
<block>
<key>equisat_decoder_equisat_4fsk_preamble_detect</key>
<param><key>id</key><value>equisat_decoder_equisat_4fsk_preamble_detect_0</value></param>
<param><key>byte_buf_size</key><value>255</value></param>
<param><key>max_symbol_ratio</key><value>0.33</value></param>
<param><key>min_preamble_len</key><value>96</value></param>
</block>
<block>
<key>equisat_decoder_equisat_fec_decoder</key>
<param><key>id</key><value>equisat_decoder_equisat_fec_decoder_0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>taps</key><value>variable_rrc_filter_taps_0</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>message_store_block_corrected</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>message_store_block_raw</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wavfile</value></param>
<param><key>label</key><value>Input WAV File</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>equisat_decoder_equisat_4fsk_preamble_detect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>equisat_decoder_equisat_4fsk_block_decode_0</source_block_id><sink_block_id>equisat_decoder_equisat_fec_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>equisat_decoder_equisat_4fsk_block_decode_0</source_block_id><sink_block_id>message_store_block_raw</sink_block_id><source_key>out</source_key><sink_key>store</sink_key></connection>
<connection><source_block_id>equisat_decoder_equisat_4fsk_preamble_detect_0</source_block_id><sink_block_id>equisat_decoder_equisat_4fsk_block_decode_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>equisat_decoder_equisat_fec_decoder_0</source_block_id><sink_block_id>message_store_block_corrected</sink_block_id><source_key>out</source_key><sink_key>store</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
